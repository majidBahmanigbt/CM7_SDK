# IAR project cmsis_enet_txrx_transfer.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8ML8_M7 NXP MIMX8ML8_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMX8ML8DVNLZ; CPU_MIMX8ML8DVNLZ_cm7; PHY_STABILITY_DELAY_US=500000U; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../components/phy/device/phyrtl8211f; ../../../../../../devices/MIMX8ML8/drivers; ../../../../../../devices/MIMX8ML8/utilities/str; ../../../../../../devices/MIMX8ML8/utilities/debug_console_lite; ../../../../../../components/silicon_id/socs; ../../../../../../components/silicon_id; ../../../../../../devices/MIMX8ML8/cmsis_drivers; ../../../../../../devices/MIMX8ML8; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../components/phy; ../../../../../../CMSIS/Driver/Include; ../../../../../../devices/MIMX8ML8/template; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: cmsis_enet_txrx_transfer.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1000
  ILINK.IlinkIcfFile: MIMX8ML8xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FLASH_TARGET; CPU_MIMX8ML8DVNLZ; CPU_MIMX8ML8DVNLZ_cm7; PHY_STABILITY_DELAY_US=500000U; MCUXPRESSO_SDK
  AARM.ADefines: DEBUG; FLASH_TARGET; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8ML8xxxxx_cm7_flash.icf
configuration ddr_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; USE_SDRAM; NDEBUG; CPU_MIMX8ML8DVNLZ; CPU_MIMX8ML8DVNLZ_cm7; PHY_STABILITY_DELAY_US=500000U; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8ML8xxxxx_cm7_ddr_ram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMX8ML8DVNLZ; CPU_MIMX8ML8DVNLZ_cm7; PHY_STABILITY_DELAY_US=500000U; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FLASH_TARGET; CPU_MIMX8ML8DVNLZ; CPU_MIMX8ML8DVNLZ_cm7; PHY_STABILITY_DELAY_US=500000U; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; FLASH_TARGET; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8ML8xxxxx_cm7_flash.icf
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; NDEBUG; CPU_MIMX8ML8DVNLZ; CPU_MIMX8ML8DVNLZ_cm7; PHY_STABILITY_DELAY_US=500000U; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8ML8xxxxx_cm7_ddr_ram.icf
  group source
    ../: cmsis_enet_txrx_transfer.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h fsl_iomuxc.h
  group doc
    ../: readme.txt
  group remoteproc
    ../: empty_rsc_table.c
  group component/phy
    ../../../../../../components/phy/device/phyrtl8211f/: fsl_phyrtl8211f.h fsl_phyrtl8211f.c
    ../../../../../../components/phy/: fsl_phy.h
  group component/silicon_id
    ../../../../../../components/silicon_id/socs/imx8/: fsl_silicon_id_soc.c
    ../../../../../../components/silicon_id/socs/: fsl_silicon_id_soc.h
    ../../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_iuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group drivers
    ../../../../../../devices/MIMX8ML8/drivers/: fsl_cache.c fsl_cache.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_enet.h fsl_enet.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_rdc.h fsl_rdc.c fsl_audiomix.h fsl_audiomix.c fsl_uart.h fsl_uart.c fsl_memory.h
    ../../../../../../devices/MIMX8ML8/cmsis_drivers/: fsl_enet_cmsis.h fsl_enet_cmsis.c fsl_enet_phy_cmsis.c fsl_enet_phy_cmsis.h
  group utilities
    ../../../../../../devices/MIMX8ML8/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMX8ML8/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group device
    ../../../../../../devices/MIMX8ML8/: fsl_device_registers.h MIMX8ML8_cm7.h MIMX8ML8_cm7_features.h system_MIMX8ML8_cm7.c system_MIMX8ML8_cm7.h
  group startup
    ../../../../../../devices/MIMX8ML8/iar/: startup_MIMX8ML8_cm7.s
  group CMSIS_driver/Include
    ../../../../../../CMSIS/Driver/Include/: Driver_ETH.h Driver_Common.h Driver_ETH_MAC.h Driver_ETH.h Driver_ETH_PHY.h Driver_Common.h Driver_Common.h Driver_ETH.h Driver_ETH_MAC.h Driver_ETH_PHY.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
