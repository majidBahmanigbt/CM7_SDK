# IAR project sai_low_power_audio.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8ML8_M7 NXP MIMX8ML8_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMX8ML8DVNLZ; CPU_MIMX8ML8DVNLZ_cm7; SRTM_DEBUG_MESSAGE_FUNC=DbgConsole_Printf; SRTM_DEBUG_VERBOSE_LEVEL=SRTM_DEBUG_VERBOSE_WARN; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../components/srtm/channels; ../../../../../components/srtm/services; ../../../../../devices/MIMX8ML8/drivers; ../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/freertos; ../../../../../middleware/multicore/rpmsg_lite/lib/include; ../../../../../devices/MIMX8ML8; ../../../../../devices/MIMX8ML8/utilities/str; ../../../../../devices/MIMX8ML8/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx8mp_m7; ../../../../../CMSIS/Core/Include; ../../../../../components/srtm/include; ../../../../../components/srtm/srtm; ../../../../../components/srtm/port; ../../../../../rtos/freertos/freertos-kernel/include; ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; NO_CRP; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: sai_low_power_audio.out
  ILINK.IlinkIcfFile: MIMX8ML8xxxxx_cm7_lpa_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMX8ML8DVNLZ; CPU_MIMX8ML8DVNLZ_cm7; SRTM_DEBUG_MESSAGE_FUNC=DbgConsole_Printf; SRTM_DEBUG_VERBOSE_LEVEL=SRTM_DEBUG_VERBOSE_WARN; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; NO_CRP; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: srtm_config.h app_srtm.c app_srtm.h FreeRTOSConfig.h rpmsg_config.h lpm.c lpm.h sai_low_power_audio.c sai_low_power_audio.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h fsl_iomuxc.h
  group remoteproc
    ../: rsc_table.c rsc_table.h remoteproc.h
  group doc
    ../: readme.txt
  group srtm/channels
    ../../../../../components/srtm/channels/: srtm_rpmsg_endpoint.h srtm_rpmsg_endpoint.c
  group srtm/services
    ../../../../../components/srtm/services/: srtm_audio_service.h srtm_audio_service.c srtm_sai_sdma_adapter.h srtm_sai_sdma_adapter.c srtm_pdm_sdma_adapter.h srtm_pdm_sdma_adapter.c srtm_i2c_service.h srtm_i2c_service.c
  group srtm/port
    ../../../../../components/srtm/port/: srtm_heap_freertos.c srtm_mutex_freertos.c srtm_sem_freertos.c srtm_message_pool.c
  group srtm/include
    ../../../../../components/srtm/include/: srtm_channel.h srtm_defs.h srtm_dispatcher.h srtm_message.h srtm_peercore.h srtm_service.h
  group srtm/srtm
    ../../../../../components/srtm/srtm/: srtm_channel.c srtm_channel_struct.h srtm_dispatcher.c srtm_dispatcher_struct.h srtm_message.c srtm_message_struct.h srtm_peercore.c srtm_peercore_struct.h srtm_service.c srtm_service_struct.h srtm_heap.h srtm_message_pool.h srtm_list.h srtm_mutex.h srtm_sem.h
  group drivers
    ../../../../../devices/MIMX8ML8/drivers/: fsl_gpio.h fsl_gpio.c fsl_i2c.h fsl_i2c.c fsl_gpt.c fsl_gpt.h fsl_gpc.c fsl_gpc.h fsl_pdm.h fsl_pdm.c fsl_pdm_sdma.h fsl_pdm_sdma.c fsl_clock.h fsl_clock.c fsl_sai.h fsl_sai.c fsl_sai_sdma.h fsl_sai_sdma.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_rdc.h fsl_rdc.c fsl_audiomix.h fsl_audiomix.c fsl_uart.h fsl_uart.c fsl_sdma.h fsl_sdma_script.h fsl_sdma.c fsl_mu.h fsl_mu.c fsl_memory.h
  group rpmsg_lite/rpmsg_lite
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_queue.c rpmsg_lite.c rpmsg_ns.c
  group rpmsg_lite/rpmsg_lite/porting/environment
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
  group rpmsg_lite/rpmsg_lite/porting/platform/imx8mp_m7
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/imx8mp_m7/: rpmsg_platform.c
  group rpmsg_lite/include
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_queue.h rpmsg_lite.h rpmsg_ns.h llist.h rpmsg_default_config.h virtio_ring.h virtqueue.h rpmsg_compiler.h rpmsg_env.h
  group rpmsg_lite/include/environment/freertos
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/freertos/: rpmsg_env_specific.h
  group rpmsg_lite/include/platform/imx8mp_m7
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx8mp_m7/: rpmsg_platform.h
  group rpmsg_lite/common
    ../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
  group rpmsg_lite/virtio
    ../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group device
    ../../../../../devices/MIMX8ML8/: fsl_device_registers.h MIMX8ML8_cm7.h MIMX8ML8_cm7_features.h system_MIMX8ML8_cm7.c system_MIMX8ML8_cm7.h
  group utilities
    ../../../../../devices/MIMX8ML8/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMX8ML8/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMX8ML8/utilities/: fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_iuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MIMX8ML8/iar/: startup_MIMX8ML8_cm7.s
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
  group freertos/freertos-kernel
    ../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable
    ../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
