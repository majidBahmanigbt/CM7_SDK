# IAR project cmsis_ecspi_int_loopback_transfer.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8ML8_M7 NXP MIMX8ML8_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMX8ML8DVNLZ; CPU_MIMX8ML8DVNLZ_cm7; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MIMX8ML8/utilities/str; ../../../../../../devices/MIMX8ML8/utilities/debug_console_lite; ../../../../../../devices/MIMX8ML8/drivers; ../../../../../../devices/MIMX8ML8/cmsis_drivers; ../../../../../../devices/MIMX8ML8; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../CMSIS/Driver/Include; ../../../../../../devices/MIMX8ML8/template; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: cmsis_ecspi_int_loopback_transfer.out
  ILINK.IlinkIcfFile: MIMX8ML8xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FLASH_TARGET; CPU_MIMX8ML8DVNLZ; CPU_MIMX8ML8DVNLZ_cm7; MCUXPRESSO_SDK
  AARM.ADefines: DEBUG; FLASH_TARGET; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8ML8xxxxx_cm7_flash.icf
configuration ddr_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMX8ML8DVNLZ; CPU_MIMX8ML8DVNLZ_cm7; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8ML8xxxxx_cm7_ddr_ram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FLASH_TARGET; CPU_MIMX8ML8DVNLZ; CPU_MIMX8ML8DVNLZ_cm7; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; FLASH_TARGET; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8ML8xxxxx_cm7_flash.icf
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8ML8xxxxx_cm7_ddr_ram.icf
  group source
    ../: cmsis_ecspi_int_loopback_transfer.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h fsl_iomuxc.h
  group doc
    ../: readme.txt
  group remoteproc
    ../: empty_rsc_table.c
  group utilities
    ../../../../../../devices/MIMX8ML8/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMX8ML8/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../devices/MIMX8ML8/drivers/: fsl_clock.h fsl_clock.c fsl_ecspi_sdma.h fsl_ecspi_sdma.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_rdc.h fsl_rdc.c fsl_audiomix.h fsl_audiomix.c fsl_uart.h fsl_uart.c fsl_ecspi.h fsl_ecspi.c fsl_sdma.h fsl_sdma_script.h fsl_sdma.c fsl_memory.h
    ../../../../../../devices/MIMX8ML8/cmsis_drivers/: fsl_ecspi_cmsis.h fsl_ecspi_cmsis.c
  group device
    ../../../../../../devices/MIMX8ML8/: fsl_device_registers.h MIMX8ML8_cm7.h MIMX8ML8_cm7_features.h system_MIMX8ML8_cm7.c system_MIMX8ML8_cm7.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_iuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMX8ML8/iar/: startup_MIMX8ML8_cm7.s
  group CMSIS_driver/Include
    ../../../../../../CMSIS/Driver/Include/: Driver_SPI.h Driver_Common.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
